# Repository akiibhai/200250330007_Akash_Soni

## EAGLE design bot_uc_board.brd

Parts:
C1, C3, C4, C5, C7, C12, C14: C-EU025-024X044; C025-024X044
C2, C6, C8, C9, C10, C13: 30pF; C025-024X044
C11: 100nF; C025-024X044
C15, C18: 100n; C050-024X044
D1, D3: Z3.6; DO35-3
D2, D4: 1N4004; DO41-10
IC1: MEGA128-M; MLF64
IC2: MAX3232CSE; SO16
JP1: JP4E; JP4
L1: L-US0204/5; 0204/5
LED1: Red; LED3MM
Q1, Q2: CRYSTALHC49U-V; HC49U-V
R1: R-EU_0204/2V; 0204V
R5: 4.7kΩ; 0204V
R7: 330Ω; 0204V
R8, R15: 0Ω; 0204V
R9: 1K5; 0207/7
R10: 10K; 0207/7
R11: 470; 0207/7
R12, R13: 68; 0207/7
RS232_SERIAL: PINHD-1X8/90; 1X08/90
SW1: CT10-XXXX-A2
U$1: 74HC4050; 74HC405
U$2: CC2520; CC2520_FOOT
U$3: SDCARD; SDCARD_FOOT
X1, X2: Q-063210; 063210
X4: PN61729-S

Connections:
3.3V_VCC: D4.C, IC1.21 (VCC), IC1.52 (VCC), IC2.16 (VCC), R5.2, R8.2
D+: D3.C, R12.1, X4.3
D-: D1.C, R9.1, R13.1, X4.2
GND: C1.1, C2.1, C3.1, C4.2, C6.1, C8.1, C9.1, C10.1, C12.2, C14.2, C15.2, D1.A, D2.A, D3.A, IC1.22 (GND), IC1.53 (GND), IC1.63 (GND), IC2.15 (GND), JP1.3, R1.2, R15.2, RS232_SERIAL.6, SW1.1, U$3.P$6 (VSS), X1.A3, X1.B3, X2.A4, X2.B4, X4.4, X4.S1, X4.S2
unnamed: D2.C, D4.A, IC1.20 (RESET), R5.1, R7.1, X1.B5
unnamed: IC1.12 ((MOSI)PB2), U$1.P$9 (D), U$2.P$2
unnamed: C7.1, IC1.64 (AVCC), L1.1
unnamed: L1.2, R8.1
unnamed: IC1.51 ((AD0)PA0), U$2.P$3
unnamed: R7.2, SW1.2
unnamed: IC1.13 ((MISO)PB3), U$2.P$1, U$3.P$7 (DAT0)
unnamed: C2.2, IC1.23 (XTAL2), Q1.2
unnamed: C8.2, IC1.24 (XTAL1), Q1.1
unnamed: C9.2, Q2.2, U$2.P$12
unnamed: C10.2, Q2.1, U$2.P$13
unnamed: IC1.11 ((SCK)PB1), U$1.P$14 (F), U$2.P$28
unnamed: C11.2, IC1.62 (AREF)
unnamed: C7.2, C11.1, R15.1
unnamed: R1.1, U$2.P$23
unnamed: C3.2, U$2.P$27
unnamed: U$1.P$4 (H), U$3.P$2 (CD/DAT3)
unnamed: C6.2, C12.1, U$1.P$1 (VCC), U$2.P$8, U$2.P$11, U$2.P$14, U$2.P$16, U$2.P$20, U$2.P$22, U$2.P$24, U$2.P$25, U$2.P$26, U$3.P$4 (VDD), X2.A1, X2.B1
unnamed: U$1.P$10 (J), U$3.P$8 (DAT1)
unnamed: U$1.P$15 (L), U$3.P$5 (CLK)
unnamed: IC1.50 ((AD1)PA1), U$1.P$5 (B)
unnamed: X1.A2, X1.B2
unnamed: C4.1, IC2.2 (V+), LED1.A, RS232_SERIAL.7, RS232_SERIAL.8, X2.A2, X2.B2, X4.1
unnamed: C14.1, IC2.6 (V-)
unnamed: C5.1, IC2.4 (C2+)
unnamed: C13.1, IC2.1 (C1+)
unnamed: C5.2, IC2.5 (C2-)
unnamed: C13.2, IC2.3 (C1-)
unnamed: IC2.14 (T1OUT), JP1.1
unnamed: IC2.7 (T2OUT), JP1.2
unnamed: C15.1, LED1.K (C), R9.2
unnamed: IC1.61 (PF0(ADC0)), X1.A5
unnamed: IC1.60 (PF1(ADC1)), X1.A6
unnamed: C18.1, IC1.38 ((A11)PC3), RS232_SERIAL.4
unnamed: C18.2, IC1.39 ((A12)PC4), RS232_SERIAL.3
unnamed: IC1.40 ((A13)PC5), RS232_SERIAL.5
unnamed: IC1.25 ((SCL/INT0)PD0), R10.2
unnamed: IC1.26 ((SDA/INT1)PD1), R11.2
unnamed: IC1.27 ((RXD1/INT2)PD2), IC2.12 (R1OUT), R12.2
unnamed: IC1.28 ((TXD1/INT3)PD3), IC2.11 (T1IN), R13.2
unnamed: IC1.59 (PF2(ADC2)), X1.A7
unnamed: IC1.58 (PF3(ADC3)), X1.A8
unnamed: IC1.57 (PF4(ADC4/TCK)), X1.A9
unnamed: IC1.56 (PF5(ADC5/TMS)), X1.A10
unnamed: IC1.55 (PF6(ADC6/TDO)), X1.A11
unnamed: IC1.54 (PF7(ADC7/TDI)), X1.A12
unnamed: IC1.47 ((AD4)PA4), X1.A13
unnamed: IC1.48 ((AD3)PA3), X1.A14
unnamed: IC1.49 ((AD2)PA2), X1.A15
unnamed: IC1.46 ((AD5)PA5), X1.A16
unnamed: X1.A1, X1.B1
unnamed: X1.A4, X1.B4
unnamed: IC1.31 ((T1)PD6), X1.B17
unnamed: IC1.32 ((T2)PD7), X1.B18
unnamed: IC1.34 (PG1(RD)), X1.B19
unnamed: IC1.9 ((IC3/INT7)PE7), X1.B16
unnamed: IC1.17 ((OC2/OC1C)PB7), X1.B6
unnamed: IC1.16 ((OC1B)PB6), X1.B7
unnamed: IC1.15 ((OC1A)PB5), X1.B8
unnamed: IC1.14 ((OC0)PB4), X1.B9
unnamed: IC1.42 ((A15)PC7), X1.B10
unnamed: IC1.41 ((A14)PC6), X1.B15
unnamed: IC1.37 ((A10)PC2), X1.B11
unnamed: IC1.36 ((A9)PC1), X1.B12
unnamed: IC1.35 ((A8)PC0), X1.B13
unnamed: IC1.29 ((IC1)PD4), X1.B14
unnamed: X2.A3, X2.B3
unnamed: IC1.7 ((OC3C/INT5)PE5), X2.A5
unnamed: IC1.8 ((T3/INT6)PE6), X2.A6
unnamed: IC1.45 ((AD6)PA6), X2.A7
unnamed: IC1.33 (PG0(WR)), X2.A8
unnamed: IC1.44 ((AD7)PA7), X2.A9, X2.A11
unnamed: IC1.6 ((OC3B/INT4)PE4), X2.A10
RXD: R10.1, RS232_SERIAL.1
TXD: R11.1, RS232_SERIAL.2

Notes on the sheet:
CS_SLAVE1
3.3V
CS_SLAVE2
+5v I/P
UART
WIRELESS
SD-CARD
RXD
TXD
RTS
DTR
CTS
GND
VCC
gnd
3.3v
12v
Microcontroller Board
Designed by: AKASH SONI

Board: 2 copper layers, 99.7 x 80.0 mm, 45 parts (0 on the bottom side), 79 nets.

## EAGLE design output_new.brd

Parts:
BUZZER: EB2209A
C1, C2: 22pF; C2.5-3
C3: 10uF; C2.5-3
DC_MOTOR1, DC_MOTOR2: PINHD-1X2; 1X02
DIS1: TUXGR_16X2_R2
DIS2, DIS3, DIS4: HD-A101; HDSP-A
IC1: L293D; DIL16
IC3: ULN2803A; DIL18
LED1, LED2, LED3: LED5MM
QF1: 8M10AHC49T; HC49U
R1, R5, R6, R7: 10k; 0204V
R2: 1k; 0204V
R3: 560; 0204V
R4: 10k; CA6V
R8, R9, R10: 8k; 0204V
STEPPER_MOTOR: PINHD-1X4; 1X04
T1, T2, T3, T4: BC547; TO92
X1, X2: Q-063210; 063210

Connections:
GND: C1.2, C2.1, DIS1.1 (GND), DIS1.16 (NC), IC1.4 (GND1), IC1.5 (GND2), IC1.12 (GND4), IC1.13 (GND3), IC3.9 (GND), LED1.K (C), LED2.K (C), LED3.K (C), R1.1, R4.A, T1.1 (E), X2.A4, X2.B4
unnamed: DC_MOTOR1.1, IC1.3 (1Y), STEPPER_MOTOR.1
unnamed: DC_MOTOR1.2, IC1.6 (2Y), STEPPER_MOTOR.2
unnamed: DC_MOTOR2.2, IC1.14 (4Y), STEPPER_MOTOR.4
unnamed: DC_MOTOR2.1, IC1.7 (2A), IC1.11 (3Y), STEPPER_MOTOR.3
unnamed: C3.2, R1.2, X1.B5
unnamed: C1.1, QF1.3, X1.B6
unnamed: IC1.2 (1A), X1.A13
unnamed: IC1.10 (3A), X1.A15
unnamed: IC1.15 (4A), X1.A16
unnamed: R2.2, X1.B19
unnamed: C2.2, QF1.1, X1.B7
unnamed: R2.1, T1.2 (B)
unnamed: BUZZER.-, T1.3 (C)
unnamed: DIS1.14 (D7), X1.B15
unnamed: DIS1.13 (D6), X1.B14
unnamed: X2.A1, X2.B1
unnamed: DIS1.11 (D4), X1.B12
unnamed: DIS1.10 (D3), X1.B11
unnamed: DIS1.9 (D2), R7.1, X1.B10
unnamed: DIS1.8 (D1), R6.1, X1.B9
unnamed: DIS1.12 (D5), X1.B13
unnamed: DIS1.15 (NC), R3.2
unnamed: DIS1.6 (E), X1.B16
unnamed: DIS1.5 (R/W), X1.B17
unnamed: DIS1.4 (RS), X1.B18
unnamed: DIS1.3 (CONTR), R4.S
unnamed: IC3.8 (I8), X1.A12
unnamed: IC3.7 (I7), X1.A11
unnamed: IC3.6 (I6), X1.A10
unnamed: IC3.5 (I5), X1.A9
unnamed: IC3.4 (I4), X1.A8
unnamed: IC3.2 (I2), R9.1, X1.A6
unnamed: IC3.1 (I1), R8.1, X1.A5
unnamed: DIS2.10 (A), DIS3.10 (A), DIS4.10 (A), IC3.18 (O1)
unnamed: DIS2.9 (B), DIS3.9 (B), DIS4.9 (B), IC3.17 (O2)
unnamed: DIS2.8 (C), DIS3.8 (C), DIS4.8 (C), IC3.16 (O3)
unnamed: DIS2.5 (D), DIS3.5 (D), DIS4.5 (D), IC3.15 (O4)
unnamed: DIS2.4 (E), DIS3.4 (E), DIS4.4 (E), IC3.14 (O5)
unnamed: DIS2.2 (F), DIS3.2 (F), DIS4.2 (F), IC3.13 (O6)
unnamed: DIS2.3 (G), DIS3.3 (G), DIS4.3 (G), IC3.12 (O7)
unnamed: DIS2.1 (CA), T2.1 (E)
unnamed: DIS2.7 (DP), DIS3.7 (DP), DIS4.7 (DP), IC3.11 (O8)
unnamed: DIS3.1 (CA), T3.1 (E)
unnamed: DIS4.1 (CA), T4.1 (E)
unnamed: R5.2, T2.2 (B)
unnamed: R6.2, T3.2 (B)
unnamed: R7.2, T4.2 (B)
unnamed: LED1.A, R8.2
unnamed: LED2.A, R9.2
unnamed: LED3.A, R10.2
unnamed: IC1.8 (VCC2), X2.A3, X2.B3
unnamed: DIS1.7 (D0), R5.1, X1.B8
unnamed: X1.A1, X1.B1
unnamed: BUZZER.+, C3.1, DIS1.2 (VCC), IC1.1 (1-2EN), IC1.9 (3-4EN), IC1.16 (VCC1), IC3.10 (CD+), R3.1, R4.E, T2.3 (C), T3.3 (C), T4.3 (C), X1.A2, X1.B2, X2.A2, X2.B2
unnamed: X1.A3, X1.B3
unnamed: X1.A4, X1.B4
unnamed: IC3.3 (I3), R10.1, X1.A7

Notes on the sheet:
12V
Designed by: AKASH SONI
OUTPUT BOARD

Board: 2 copper layers, 100.0 x 80.0 mm, 33 parts (0 on the bottom side), 58 nets.

## EAGLE design bot_power_supply.brd

Parts:
ADP1612, ADP1612_1: ADP1612_DEV; ADP1612_FOOT
C1, C2, C3: 4.7uF; C2.5-3
C8: 0.1uF; C2.5-2
C10, C11, C12: 10uF; C2.5-2
CCOMP: 3300pF; C2.5-3
CCOMP1: 1800pF; C2.5-3
CIN, CIN1: 10uF; C2.5-3
COUT, COUT1: 10uF; C2.5-3
CSS, CSS1: 33nF; C2.5-3
D1, D2: 1N5817-T; DO41-7.6
D3, D4: 1N4004; DO41-10
I/P, I/P1: JP1E; JP1
L1: 4.7uH; 0204/7
L2: 2.2uH; 0207/7
L3: 10uH; 0204/7
LED1, LED3: LED3MM
LED2: LEDLD260; LD260
MCP73837: MCP73837-DEV; MCP73837
O/P_3.3V, O/P_5V, O/P_12V: JP1E; JP1
O/P_TO_BATTERY: JP1E; JP1
R1: 30k; 0204V
R2, R4: 10k; 0204V
R3: 86.6k; 0204V
R5, R7, R8: 1k; 0204V
R6: 100Ω; 0207/10
R9: THERMISTOR-7,5; R-7,5
RCOMP: 6.8k; 0204V
RCOMP1: 22k; 0204V
RPROG: R-US_0204/2V; 0204V
TPS63002: TPS63002
USB: PN61729
X1, X2: Q-063210; 063210

Connections:
GND: ADP1612.FREQ, ADP1612.GND, ADP1612_1.FREQ, ADP1612_1.GND, C1.1, C2.1, C3.1, C8.2, C10.2, C11.2, C12.2, CCOMP.2, CCOMP1.2, CIN.2, CIN1.2, COUT.2, COUT1.2, CSS.2, CSS1.2, I/P.2, I/P1.2, MCP73837.PG', O/P_3.3V.1, O/P_5V.2, O/P_12V.2, O/P_TO_BATTERY.2, R2.1, R4.1, R9.2, RPROG.1, TPS63002.GND, TPS63002.PGND, USB.4, X1.A4, X1.B4, X2.A4, X2.B4
unnamed: ADP1612.COMP, RCOMP.2
unnamed: CCOMP.1, RCOMP.1
unnamed: COUT.1, D1.C, O/P_5V.1, R1.1, X1.A2, X1.B2, X2.A2, X2.B2
unnamed: ADP1612.FB, R1.2, R2.2
unnamed: L2.1, TPS63002.L1
unnamed: ADP1612.SS, CSS.1
unnamed: ADP1612.SW, D1.A, L1.2
unnamed: ADP1612_1.COMP, RCOMP1.2
unnamed: CCOMP1.1, RCOMP1.1
unnamed: COUT1.1, D2.C, O/P_12V.1, R3.1, X1.A3, X1.B3, X2.A3, X2.B3
unnamed: L2.2, TPS63002.L2
unnamed: ADP1612_1.FB, R3.2, R4.2
unnamed: ADP1612_1.SS, CSS1.1
unnamed: MCP73837.VSS, R8.2
unnamed: ADP1612_1.SW, D2.A, L3.2
unnamed: MCP73837.STAT1, R5.2
unnamed: MCP73837.STAT2, R7.2
unnamed: ADP1612.VIN, ADP1612_1.VIN, C3.2, C10.1, CIN.1, CIN1.1, I/P.1, I/P1.1, L1.1, L3.1, MCP73837.VBAT, O/P_TO_BATTERY.1, R6.1, TPS63002.EN, TPS63002.PS/SYNC, TPS63002.VIN, TPS63002.VINA
unnamed: C8.1, R6.2
unnamed: MCP73837.PROG1, RPROG.2
unnamed: MCP73837.THERM, R9.1
unnamed: C2.2, D3.A, MCP73837.VUSB, USB.1
unnamed: LED1.K (C), R5.1
unnamed: LED2.K (C), R7.1
unnamed: D3.C, D4.C, LED1.A, LED2.A, LED3.A
unnamed: C1.2, D4.A, MCP73837.VAC
unnamed: LED3.K (C), R8.1
unnamed: C11.1, C12.1, O/P_3.3V.2, TPS63002.FB, TPS63002.VOUT, X1.A1, X1.B1, X2.A1, X2.B1

Notes on the sheet:
2A,20V
3.3V
12V
GND

Board: 2 copper layers, 100.0 x 81.3 mm, 50 parts (2 on the bottom side), 29 nets.

## EAGLE design BOT_Input_board.brd

Parts:
BATTERY_SENSOR: JP4E; JP4
I/P_FROM_IR_SENSOR: JP2E; JP2
I/P_FROM_RH: JP4E; JP4
I/P_FROM_TRANSRECEIVER: JP2E; JP2
I/P_FROM_ULTRASONIC_SENSOR: JP4E; JP4
X1, X2: Q-063210; 063210

Connections:
GND: BATTERY_SENSOR.3, I/P_FROM_IR_SENSOR.1, I/P_FROM_RH.4, I/P_FROM_TRANSRECEIVER.2, I/P_FROM_ULTRASONIC_SENSOR.4, X1.A4, X1.B4
unnamed: I/P_FROM_ULTRASONIC_SENSOR.3, X2.A6
unnamed: X1.A1, X1.B1
unnamed: BATTERY_SENSOR.1, I/P_FROM_IR_SENSOR.2, I/P_FROM_RH.1, I/P_FROM_TRANSRECEIVER.1, I/P_FROM_ULTRASONIC_SENSOR.1, X1.A2, X1.B2
unnamed: X1.A3, X1.B3
unnamed: I/P_FROM_ULTRASONIC_SENSOR.2, X2.A5
unnamed: I/P_FROM_IR_SENSOR.3, X2.A7
unnamed: I/P_FROM_TRANSRECEIVER.3, X2.A8
unnamed: I/P_FROM_RH.2, X2.A9
unnamed: BATTERY_SENSOR.2, X2.A10
unnamed: BATTERY_SENSOR.4, X2.A11

Notes on the sheet:
5V VCC
Vcc
GND
TRIGGER
Echo
OUT
VCC
Designed by: AKASH SONI

Board: 2 copper layers, 100.0 x 80.0 mm, 7 parts (0 on the bottom side), 11 nets.

## EAGLE design 15-15 AC_DC_Dual_power_supply.brd

Parts:
7915T2: 7915T; TO220H
+15V2: 7815T; TO220H
C1, C3: 2200uF; C2.5-2
C2, C4: 0.22uF; C2.5-2
C5: 100uF; C2.5-2
C6: 0.1uF; C2.5-2
C7, C8: 0.1uF; C2.5-3
D1, D2, D3, D4: 1N4004; DO41-10
O/P_+15V1: JP1E; JP1
O/P_-15V1: JP1E; JP1
TRANSFORMER_O/P: JP2E; JP2

Connections:
GND: 7915T2.1 (GND), +15V2.2 (GND), C1.1, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C8.1, TRANSFORMER_O/P.2
unnamed: +15V2.1 (VI), C1.2, C2.2, D3.C, D4.C
unnamed: +15V2.3 (VO), C5.2, C7.1, O/P_+15V1.1
unnamed: 7915T2.3 (VO), C6.1
unnamed: C8.2, O/P_-15V1.2
unnamed: 7915T2.2 (VI), C3.1, C4.1, D1.A, D2.A
unnamed: D2.C, D4.A, TRANSFORMER_O/P.1
unnamed: O/P_+15V1.2, O/P_-15V1.1
unnamed: D1.C, D3.A, TRANSFORMER_O/P.3

Notes on the sheet:
-15v
+15v

Board: 2 copper layers, 32.7 x 43.2 mm, 17 parts (0 on the bottom side), 9 nets.

## EAGLE design 5v_AC_DC.brd

Parts:
C1: 1000uF; C2.5-3
C2, C3: 0.33uF; C2.5-3
D1, D2, D3, D4: 1N4004; DO41-10
I/P: 12AC; JP1
IC1: 7805L; TO92
O/P: 5VDC; JP1

Connections:
GND: C1.2, C2.2, C3.2, D1.A, D4.A, IC1.2 (GND), O/P.2
unnamed: C3.1, IC1.1 (VO), O/P.1
unnamed: C1.1, C2.1, D2.C, D3.C, IC1.3 (VI)
unnamed: D2.A, D4.C, I/P.1
unnamed: D1.C, D3.A, I/P.2

Board: 2 copper layers, 27.9 x 23.8 mm, 10 parts (0 on the bottom side), 5 nets.

## Commit log

2020-09-30 Set theme jekyll-theme-cayman
2020-10-01 Create EHD
2020-10-08 Create bot
